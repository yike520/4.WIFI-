# Keil uVision project WSP8266_AP方式下WIFI遥控程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: WSP8266_AP方式下WIFI遥控程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: WSP8266_AP方式下WIFI遥控程序.c
